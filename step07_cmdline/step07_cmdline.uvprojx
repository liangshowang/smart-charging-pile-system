# Keil uVision project step07_cmdline.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: step07_cmdline +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: cmd /c "if not exist .\Flash mkdir .\Flash && copy "$L@L.hex" .\Flash\ && copy "$L@L.bin" .\Flash\"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: .\App;.\CMSIS;.\StdLib
  asm include: .\App;.\CMSIS;.\StdLib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./App/: main.c loopbuf.c io_config.c systick.c drv_uart0.c frame_parser.c cmd_line.c
  group CSL\StdPD
    ./StdLib/: SWM320_adc.c SWM320_exti.c SWM320_gpio.c SWM320_i2c.c SWM320_pwm.c SWM320_timr.c SWM320_wdt.c SWM320_dma.c SWM320_flash.c SWM320_port.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c SWM320_uart.c
  group CSL\CMSIS
    ./CMSIS/: system_SWM320.c startup_SWM320.s
