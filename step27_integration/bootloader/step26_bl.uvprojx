# Keil uVision project step26_bl.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: step26_bl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: cmd /c "if not exist .\Flash mkdir .\Flash && copy "$L@L.hex" .\Flash\ && copy "$L@L.bin" .\Flash\"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS;.\StdLib;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\App;.\task;.\drv;.\drvp;.\softpack\sysprt;.\softpack\at_dev;.\softpack\air_man;.\ota;..\
  asm include: .\CMSIS;.\StdLib;.\FreeRTOS;.\FreeRTOS\portable\RVDS\ARM_CM3;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./: main.c boot_config.c
    ./App/: io_config.c
  group task
    ./task/: task_start.c
  group ota
    ./ota/: ota_state.c ota_flash.c
  group drv
    ./drv/: drv_uart0.c drv_uart1.c drv_gpio.c drv_loop.c
  group drvp
    ./drvp/: drvp_gpio.c drvp_uart0.c drvp_uart1.c
  group FreeRTOS
    ./FreeRTOS/: tasks.c queue.c list.c timers.c croutine.c event_groups.c
  group FreeRTOS\port
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ./StdLib/: SWM320_uart.c SWM320_gpio.c SWM320_port.c SWM320_flash.c SWM320_timr.c SWM320_pwm.c SWM320_exti.c SWM320_wdt.c SWM320_dma.c SWM320_adc.c SWM320_i2c.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c
  group CSL\CMSIS
    ./CMSIS/: system_SWM320.c startup_SWM320.s
  group softpack\sysprt
    ./softpack/sysprt/: sysprt.c
  group softpack\at_dev
    ./softpack/at_dev/: at_dev.c
  group softpack\air_man
    ./softpack/air_man/: air_man.c
