# Keil uVision project step25_bl.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: step25_bl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: cmd /c "if not exist .\Flash mkdir .\Flash && copy "$L@L.hex" .\Flash\ && copy "$L@L.bin" .\Flash\"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS;.\StdLib;..\
  asm include: .\CMSIS;.\StdLib;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./: main.c
  group CSL\StdPD
    ./StdLib/: SWM320_uart.c SWM320_gpio.c SWM320_port.c
  group CSL\CMSIS
    ./CMSIS/: system_SWM320.c startup_SWM320.s
